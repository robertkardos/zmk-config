## boards/flat_2x7x5/Kconfig.flat_2x7x5_right
```kconfig
config BOARD_FLAT_2X7X5_RIGHT
    select SOC_NRF52840_QIAA
    imply RETAINED_MEM
    imply RETENTION
    imply RETENTION_BOOT_MODE
```
